options:
  parameters:
    author: LPRO13
    generate_options: qt_gui
    id: Rx_AM
    output_language: python
    title: Receptor AM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:CARD=Generic,DEV=0
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '40'
    gain: '1'
    samp_rate: 1.92e6
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: 48e3
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 106.9e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 1.92e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_imag_0, '0', blocks_selector_0, '1']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_arg_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_imag_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
