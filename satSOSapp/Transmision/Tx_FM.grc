options:
  parameters:
    author: LPRO13
    generate_options: qt_gui
    id: Tx_FM
    output_language: python
    title: Tx_FM
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 88.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.85'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/carreira/GNURadio/GNURadio/Archivos/C H I L L V I B E S Chill & aesthetic music playlist.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: 480e3
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: ccc
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    gain: '30.0'
    samp_rate: 1.92e6
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
